# Keil uVision project BD961.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F107RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: BD961V5.01b +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_CL, USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\User;..\User\AKQ;..\User\DMA;..\User\TIMER;..\User\UART4;..\User\USART2;..\User\USART3;..\User\NVIC;..\User\CAN
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_cl.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLB
    ../Libraries/FWlib/src/: misc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_can.c
  group USER
    ../User/: main.c stm32f10x_it.c
    ../User/USART3/: usart3.c
    ../User/USART2/: usart2.c
    ../User/UART4/: usart4.c
    ../User/TIMER/: timer.c
    ../User/NVIC/: nvic.c
    ../User/DMA/: dma.c
    ../User/AKQ/: akq.c
    ../User/CAN/: can.c
